File: Monitor-Raspberry.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: VER1.0: добавил плату под ссд
Other:
- note added: "А6.7"
